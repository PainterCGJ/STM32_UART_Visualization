# Keil uVision project MDK_Pro.uvprojx, settings and files
target UART_Visualization (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,USE_OS
  c include: ..\Code\CMSIS;..\Code\Application\inc;..\Code\BSP\delay;..\Code\BSP\sys;..\Code\Interface\inc;..\Code\STM32F10x_StdPeriph_Driver\inc;..\Code\FreeRTOS;..\Code\FreeRTOS\inc;..\Code\FreeRTOS\port\RVDS\ARM_CM3;..\Code\BSP\sys;..\Code\BSP\systick;..\Code\BSP\oled;..\Code\BSP\os;..\Code\BSP\i2c
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Code/Application/src/: main.c
  group CMSIS
    ../Code/CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group Driver
    ../Code/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS/port
    ../Code/FreeRTOS/port/MemMang/: heap_4.c
    ../Code/FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group FreeRTOS/src
    ../Code/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group BSP
    ../Code/BSP/sys/: sys.c
    ../Code/BSP/os/: os_bsp.c
    ../Code/BSP/oled/: oled_bsp.c
    ../Code/BSP/systick/: systick_bsp.c
    ../Code/BSP/i2c/: stm32f1_i2c_bsp.c
